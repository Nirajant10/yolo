Commit message: Added my independent ROS 2 nodes

File: my_amr_cpp/urdf/Assem1_urdf.urdf (robot description, URDF)
Before this commit: robot Assem1_urdf, 7 links, 6 joints
Joints:
- joint base_footprint_joint: origin xyz=0.0 -0.075 0.0 rpy=0 0 0 -> xyz=0.125 -0.075 0.0 rpy=0 0 0
